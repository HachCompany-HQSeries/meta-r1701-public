RDEPENDS_${PN} = "\
    packagegroup-core-tools-debug \
"
