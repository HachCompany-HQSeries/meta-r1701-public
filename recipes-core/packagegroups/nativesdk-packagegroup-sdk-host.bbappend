# Copyright (C) 2017 Digi International.
# Copyright (C) 2018 HACH Company.

RDEPENDS_${PN} += " \
    nativesdk-protobuf \
"
