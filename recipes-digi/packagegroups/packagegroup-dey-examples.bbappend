RDEPENDS_${PN} = ""
RDEPENDS_${PN}_append_ccimx6 = ""
RDEPENDS_${PN}_append_ccimx6ul = ""
