# Copyright (C) 2018 HACH Company

require recipes-digi/swu-images/swu.inc

#IMG_NAME = "${IMAGE_BASENAME}"
#IMG_NAME = "${@get_baseimg_pn(d)}"
