require recipes-digi/swu-images/swu.inc
