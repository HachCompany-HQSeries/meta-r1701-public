# Copyright (C) 2020 HACH Company
require recipes-digi/swu-images/swu.inc
