require recipes-digi/swu-images/swu.inc
IMG_NAME = "hqseries-portable-image"
