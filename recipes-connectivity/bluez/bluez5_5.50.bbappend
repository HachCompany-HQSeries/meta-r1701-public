INITSCRIPT_NAME_${PN}-init_remove = "bluetooth-init"
