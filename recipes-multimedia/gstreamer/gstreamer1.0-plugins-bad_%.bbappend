GST1.0-PLUGINS-BAD_SRC = "gitsm://github.com/nxp-imx/gst-plugins-bad.git;protocol=https"
