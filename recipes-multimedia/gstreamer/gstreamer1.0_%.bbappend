GST1.0_SRC = "gitsm://github.com/nxp-imx/gstreamer.git;protocol=https"

