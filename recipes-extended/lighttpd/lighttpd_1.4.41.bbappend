RDEPENDS_${PN} += " \
    lighttpd-module-cgi \
    lighttpd-module-fastcgi \
"

