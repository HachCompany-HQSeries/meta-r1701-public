RDEPENDS_${PN} += " \
    lighttpd-module-fastcgi \
"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

