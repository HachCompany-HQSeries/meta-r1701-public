# For some reason Google has deleted the original branch 3.4.X and out protobuf does not compile. hence just change it
# to master branch. We use special GIT COmmit SHA.
SRC_URI = "git://github.com/google/protobuf.git;branch=master"
