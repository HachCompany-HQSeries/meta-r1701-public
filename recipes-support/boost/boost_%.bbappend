BOOST_LIBS = "\
    system \
    thread \
"
