#
# Only change here is 'http' to 'https' since upstream expect to clone using https. Post checkout custom SRCREV will be
# checked out.
#
SRC_URI = "git://salsa.debian.org/iso-codes-team/iso-codes.git;protocol=https;branch=main;"
