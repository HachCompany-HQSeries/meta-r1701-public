SRC_URI = "https://download.libsodium.org/libsodium/releases/old/${BPN}-${PV}.tar.gz"
